# Keil uVision project Archi_EvaBot.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: LM3S9B92 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Archi_EvaBot
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./src/: Leds.s Utils.s Program.s Bumpers.s Switches.s RK_Config_Moteur.s Motors.s Time.s
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
