		AREA    |.text|, CODE, READONLY
			
		ENTRY
		IMPORT MOTEUR_DROIT_ON
		IMPORT MOTEUR_DROIT_OFF
		IMPORT MOTEUR_GAUCHE_ON
		IMPORT MOTEUR_GAUCHE_OFF
		IMPORT MOTEUR_DROIT_AVANT
		IMPORT MOTEUR_GAUCHE_AVANT
		
		EXPORT MOTORS_ON
		EXPORT MOTORS_OFF
		EXPORT FORWARD_MOTION

 ;; launch both right and left motors
MOTORS_ON
		PUSH {LR}
		BL MOTEUR_DROIT_ON
		BL MOTEUR_GAUCHE_ON
		POP {LR}
		
		BX LR
		
 ;; extinct both right and left motors
MOTORS_OFF

		PUSH {LR}
		BL MOTEUR_DROIT_OFF
		BL MOTEUR_GAUCHE_OFF
		POP {LR}
		
		BX LR
		
 ;; Make the bot going forward
FORWARD_MOTION
		PUSH {LR}
		BL MOTEUR_GAUCHE_AVANT
		BL MOTEUR_DROIT_AVANT
		POP {LR}
		
		BX LR

		END